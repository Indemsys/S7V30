<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\S7V30_bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
