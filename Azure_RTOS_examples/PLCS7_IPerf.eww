<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PLCS7_IPerf.ewp</path>
    </project>
    <batchBuild />
</workspace>
